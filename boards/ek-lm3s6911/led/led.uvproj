# Keil uVision project led.uvproj, settings and files
target LED (ARM-ADS)
  device: LM3S6911 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: led
  c flags: Optim=1
  c include: ..\..\..\inc;..\..\..\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./src/: led.c Startup.s
  group Library
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
