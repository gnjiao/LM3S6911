# Keil uVision project boot_eth.uvproj, settings and files
target boot_eth (ARM-ADS)
  device: LM3S6432 Luminary Micro
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x17FFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: boot_eth
  BeforeMake: armcc --device DLM -I . -E -o ../../../boot_loader/bl_config.inc ../../../boot_loader/bl_config.c
  AfterMake: fromelf --bin --output .\rvmdk\boot_eth.bin .\rvmdk\boot_eth.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S101
  c include: .;..\..\..;..\..\..\boot_loader;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\boot_loader\bl_link.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../boot_loader/: bl_autobaud.c bl_can.c bl_check.c bl_decrypt.c bl_enet.c bl_flash.c bl_i2c.c bl_main.c bl_packet.c bl_ssi.c bl_startup_rvmdk.S bl_uart.c bl_usb.c bl_usbfuncs.c
  group Documentation
    ../../../boot_loader/: readme.txt
